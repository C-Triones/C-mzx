# Keil uVision project project.uvprojx, settings and files
target FreeRTOS_STM32F1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\User\User_App;..\..\User\User_Driver;..\..\User\Font_And_Bmp;..\..\User\User_GUI;..\..\User\Util
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../../User/: main.c includes.h FreeRTOSConfig.h
  group User_GUI
    ../../User/User_GUI/: GUI.c GUI_OLED.c
  group User_App
    ../../User/User_App/: app.h app.c app_walk.c app_input.c app_work.c app_flash.c app_echo.c app_outfireRobotOneWork.c app_outfireRobotTwoWork.c app_rescueRobotWork.c app_findfire.c
  group User_Driver
    ../../User/User_Driver/: driver.h driver.c driver_photoelectric_switch.c driver_oled.c driver_steering_engine_speed.c driver_fan_motor.c driver_key.c driver_echo.c driver_linearMovement.c HJ_USART.c HJ_USART_IRQ.c
  group BSP
    ../../User/bsp/: bsp.h bsp.c stm32f10x_it.c stm32f10x_assert.c bsp_cpu_flash.c BSP_IIC_SW.c BSP_EXTI.c BSP_GPIO.c BSP_Timer.c
    ../../User/bsp/src/: bsp_led.c bsp_uart_fifo.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_cl.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dma.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt
  group Font_And_Bmp
    ../../User/Font_And_Bmp/: oled_bmp.h oled_font.h
  group UTIL
    ../../User/Util/: util.c
software components: CMSIS:CORE 5.1.1
