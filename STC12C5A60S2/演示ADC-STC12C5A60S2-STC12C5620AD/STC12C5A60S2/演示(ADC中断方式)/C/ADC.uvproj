# Keil uVision project ADC.uvproj, settings and files
target Target 1 (MCS-51)
  device: IAP12C5A60S2 IAP12C5A60S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: ADC +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ADC.c
